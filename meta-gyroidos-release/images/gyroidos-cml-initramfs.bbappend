include gyroidos-relese.inc
