include gyroidos-release.inc
